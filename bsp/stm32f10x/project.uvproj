# Keil uVision project project.uvproj, settings and files
target rtthread-stm32 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rtthread-stm32 +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .;..\..\components\CMSIS\Include;..\..\components\dfs;..\..\components\dfs\include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\init;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;Libraries\STM32F10x_StdPeriph_Driver\inc;applications;drivers;.\applications\net;..\..\components\dfs\filesystems\jffs2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group Applications
    applications/: application.c startup.c
    ./applications/: apppubulic.c
  group Drivers
    drivers/: board.c stm32f10x_it.c usart.c spibus.c spiflash.c gpio.c gpio_pin.c gpio_exti.c rtc.c
    ./drivers/: untils.c
  group STM32_StdPeriph
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_rtc.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_cec.c misc.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_fs.c dfs_file.c dfs_posix.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group DeviceDrivers
    ../../components/drivers/rtc/: rtc.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Components
    ../../components/init/: components.c
  group zmodem
    ../../components/utilities/zmodem/: rz.c sz.c zcore.c zdevice.c zstart.c
